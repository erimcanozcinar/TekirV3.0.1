Commit message: ceri cidiyorum

File: rsc/urdf/tekir3mesh_camera.urdf (robot description, URDF)
Before this commit: robot tekirV3, 18 links, 17 joints
Joints:
- joint face_front_to_depth_camera_front_camera: origin xyz=0.290 0 0.105 rpy=0.0 0.0 0 -> xyz=0.290 0 0.3 rpy=0.0 0.349066 0.0
